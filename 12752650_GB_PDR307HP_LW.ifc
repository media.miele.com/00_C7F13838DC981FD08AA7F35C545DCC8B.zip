Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 5087782b-822a-423d-9eec-e7aeb0624138, NumberOfSaves: 1]
File name: 0001
Time: 2025-04-29T14:51:52+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12752650_GB_PDR307HP_LW:52307161_GB_12752650_PDR307HP_LW, (2)
In: Default
Type - Material: z_Miele_Design_Orange, z_Miele_Design_Steel_Chrom, z_Miele_Design_Powder Coat_Grey, z_Miele_Design_Glass, z_Miele_Design_Powder Coat_Lotus White, Polypropylene, z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Connection_Water_OUT, z_Miele_Design_Zinc_Steel, <Unnamed>, z_Miele_Connection_Electric, Default
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: 52307161_GB_12752650_PDR307HP_LW; sets with these values: 2
